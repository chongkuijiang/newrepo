# Keil uVision project TMC01.uvproj, settings and files
target TMC01 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TMC +hex
  c flags: Optim=1 wLevel=2
  c include: .\SRC\User;.\SRC\Lib;.\SRC\OS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./SRC/User/: main.c user1.c user2.c AT24C16.c
  group Cofg
    ./SRC/Lib/: STM32F10x.s cortexm3_macro.s
    ./SRC/OS/: os_cpu_a.asm
  group Lib
    ./SRC/Lib/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x.lib
  group OS
    ./SRC/OS/: os_core.c os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
