# IAR project PID_Temper.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\Base; ..\library\inc; ..\library\src; ..\Driver; ..\Package; ..\App
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PID_Temper.srec
  ILINK.IlinkOutputFile: PID_Temper.out
  ILINK.IlinkIcfFile: ..\Base\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group App
    ../App/: Process.c
  group Driver
    ../Driver/: adc.c Dac.c Exit.c Flash.c stm32f10x_it.c SysInit.c Time.c uart.c
  group EWARM
    ../Base/: cortexm3_macro.s stm32f10x_vector.c
  group FWLIB
    ../library/src/: stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group Package
    ../Package/: ds18b20.c Fuzzy.c Max6675.c Modbus.c Pid.c Readtemp.c
