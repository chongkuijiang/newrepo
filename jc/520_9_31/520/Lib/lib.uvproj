# Keil uVision project lib.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f10x (library)
  c flags: Optim=1 wLevel=2
  c include: C:\Keil\ARM\INC\FWLib\inc;C:\Keil\ARM\INC\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: lib.c user.c bps.c
  group New Group
    C:/Keil/ARM/INC/FWLib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
