# Keil uVision project CW401-TFT大通迅板.uvproj, settings and files
target C401-TFT (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: C401-TFT +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CODE;..\FWLib;..\FWLib\inc;..\STemWin\inc;..\STemWin\Config
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../FWLib/: startup_stm32f10x_md.s core_cm3.c system_stm32f10x.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Code
    ../CODE/: stm32f10x_it.c sys.c main.c CRC.c usart.c Font20.c font14.c 24cxx.c myiic.c
  group STemWin
    ../STemWin/Lib/: STemWin532_CM3_Keil.lib
    ../STemWin/OS/: GUI_X.c
    ../STemWin/Config/: GUIConf.c LCD_X_Serial.c GUIDRV_Template.c LCDConf.c
